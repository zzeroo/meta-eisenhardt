SUMMARY = "Basic minimal image that fully supports the target device hardware."

IMAGE_FEATURES += "splash ssh-server-dropbear"

LICENSE = "GPL"

IMAGE_INSTALL = ""

inherit core-image
